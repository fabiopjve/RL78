<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Exemplo1\exemplo6_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Exemplo2\exemplo6_2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


