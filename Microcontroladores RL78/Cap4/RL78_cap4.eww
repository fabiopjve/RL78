<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Exemplo1\Exemplo4_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Exemplo2\Exemplo4_2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Exemplo3\Exemplo4_3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Exemplo4\exemplo4_4.ewp</path>
  </project>
  <batchBuild/>
</workspace>


