# IAR project Exemplo4_2.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkr5f100le.xcl
  group (top)
    ./: exemplo4_2.c
